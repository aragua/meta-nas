DEPENDS_remove = "gnome-desktop3"

REQUIRED_DISTRO_FEATURES = ""
