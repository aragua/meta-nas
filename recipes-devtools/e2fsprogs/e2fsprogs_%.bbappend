EXTRA_OECONF += "--libdir=${base_libdir} --sbindir=${base_sbindir} \
                --enable-elf-shlibs \
                --disable-libblkid --enable-verbose-makecmds"