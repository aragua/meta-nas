require transmission.inc

LICENSE = "GPLv2 & GPLv3"
LIC_FILES_CHKSUM = "file://COPYING;md5=0dd9fcdc1416ff123c41c785192a1895"

#SRCREV = "ed754f96051b9f761ad0891b92ae5bee05b7538e"

SRC_URI += " file://0006-libsystemd.patch "

SRC_URI[md5sum] = "3fce404a436e3cd7fde80fb6ed61c264"
SRC_URI[sha256sum] = "3a8d045c306ad9acb7bf81126939b9594553a388482efa0ec1bfb67b22acd35f"