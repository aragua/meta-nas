include nas-image-minimal.inc

SUMMARY = "A multimedia NAS image"

IMAGE_INSTALL += " \
	      gerbera \
	      transmission-web \
	      "